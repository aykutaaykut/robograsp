Commit message: Trying to pick

File: panda_sim_gazebo/objects/basic_cube.urdf (robot description, URDF)
Before this commit: robot basic_box, 1 links, 0 joints
Links:
- link box_link: geometry collision box size=0.02 0.02 0.02; visual box size=0.02 0.02 0.02
